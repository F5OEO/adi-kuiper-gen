options:
  parameters:
    generate_options: qt_gui
    id: WEBFFT
    output_language: python
    title: webfft
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport asyncio\nimport threading\nimport websockets\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self, ws_address=\"ws://127.0.0.1:8000/waterfall\", fft_size=4096):\n        gr.sync_block.__init__(\n            self,\n            name=\"WebSocket FFT Receiver\",\n            in_sig=None,\n            out_sig=[(np.float32, fft_size)]  # vector output of fft_size\n        )\n        self.ws_address = ws_address\n        self.fft_size = fft_size\n        self.buffer = None\n        self.lock = threading.Lock()\n        self.running = True\n\n    def start(self):\n        def runner():\n            asyncio.run(self.spectrum_loop())\n        self.thread = threading.Thread(target=runner, daemon=True)\n        self.thread.start()\n        return super().start()\n\n    def stop(self):\n        self.running = False\n        return super().stop()\n\n    async def spectrum_loop(self):\n        async with websockets.connect(self.ws_address) as ws:\n            while self.running:\n                raw = await ws.recv()\n                spec = np.frombuffer(raw, dtype=np.float32)\n\n                # Convert to dB scale (power spectrum)\n                spec_db = 10 * np.log10(spec + 1e-12)\n\n                with self.lock:\n                    self.buffer = spec_db\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        with self.lock:\n            if self.buffer is not None:\n                out[0][:] = self.buffer[:self.fft_size]\n            else:\n                out[0][:] = np.zeros(self.fft_size, dtype=np.float32)\n        return 1\n\n"
    fft_size: '4096'
    ws_address: '"ws://10.0.0.107:8000/waterfall"'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '4096'
    x_start: '0'
    x_step: '10.0'
    ymax: '100'
    ymin: '0'
  states: {}

connections:
- [epy_block_0, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
